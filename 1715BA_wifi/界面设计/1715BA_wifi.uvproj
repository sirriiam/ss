# Keil uVision project 1715BA_wifi.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C660 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) XRAM (0-0xFF) IROM(0-0x3FFF) CLOCK(33000000) MODP2
  output: HE-1715BA-wifi +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./SRC/: main.c Initial.c Keydeal.c Display.c MySub.c irq.c SendCode.c
